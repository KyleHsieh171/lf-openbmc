FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI +="file://rmcv2.cfg"
